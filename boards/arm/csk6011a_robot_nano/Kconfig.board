## boards/arm/csk6011a_robot_nano/Kconfig.board
```kconfig
# SPDX-License-Identifier: Apache-2.0

config BOARD_CSK6011A_ROBOT_NANO
   bool "csk6011a_robot_nano Board"
   depends on SOC_CSK6
```
